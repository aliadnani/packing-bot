Commit message: Two arms

File: urdf/ur5_robotiq_140.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_140, 18 links, 17 joints
Joints:
- joint world_arm_joint: origin xyz=0 0 0.78 rpy=0.0 0.0 0 -> xyz=0 0 0.0 rpy=0.0 0.0 0
